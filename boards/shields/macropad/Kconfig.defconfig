## boards/shields/macropad/Kconfig.defconfig
```kconfig
if SHIELD_MACROPAD9

# Máximo 16 caracteres
config ZMK_KEYBOARD_NAME
    default "MacroPad9"

endif
```
